# Keil uVision project VoltWatch.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ADuCM410 Analog Devices
  pack: AnalogDevices.ADuCM410_DFP.1.7.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: VoltWatch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.7.0
