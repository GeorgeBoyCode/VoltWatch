# Keil uVision project ADC.uvprojx, settings and files
target ADC (6240000::V6.24::ARMCLANG)
  device: ADuCM320 Analog Devices
  pack: AnalogDevices.ADuCM320_DFP.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: ..\..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./src/: ADC_Demo.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0, Device:Peripheral Libraries:ADC 1.0.0, Device:Peripheral Libraries:DAC 1.0.0, Device:Peripheral Libraries:DIO 1.0.0, Device:Peripheral Libraries:INT 1.0.0, Device:Peripheral Libraries:UART 1.0.0, Device:Peripheral Libraries:WDT 1.0.0
