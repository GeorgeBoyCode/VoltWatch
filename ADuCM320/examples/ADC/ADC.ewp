# IAR project ADC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM320 AnalogDevices ADuCM320
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Common; $EW_DIR$\arm\CMSIS\Include; $EW_DIR$\arm\inc\analogdevices
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.hex
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    src/: ADC_Demo.c
  group common
    ../../common/: AdcLib.c DacLib.c DioLib.c IntLib.c UrtLib.c WdtLib.c
  group Startup_Code
    ../../common/IAR/: startup_ADuCM320.s
